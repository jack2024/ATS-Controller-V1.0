# Keil uVision project TestSPI_MCP23S17.uvprojx, settings and files
target TestSPI_MCP23S17 (ARM-ADS)
  device: STM32F070CB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: TestSPI_MCP23S17 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F070xB
  c misc: --C99
  c include: ../Inc;                                                                                                            ../Drivers/STM32F0xx_HAL_Driver/Inc;                                                                                                            ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;                                                                                                            ../Drivers/CMSIS/Include;                                                                                                            ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;                                                                       ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                                       ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pcd.c stm32f0xx_hal_iwdg.c
  group Application/User
    ../Src/: stm32f0xx_hal_msp.c stm32f0xx_it.c main.c usbd_desc.c usbd_conf.c usb_device.c usbd_cdc_if.c fonts.c ssd1306.c
    ../Inc/: fonts.h mxconstants.h ssd1306.h
  group Application/MDK-ARM
    ./: startup_stm32f070xb.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 4.1.0
